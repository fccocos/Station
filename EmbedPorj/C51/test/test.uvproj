# Keil uVision project test.uvproj, settings and files
target test (MCS-51)
  device: AT89C52 Atmel
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ../../custom_include;D:\Keil_v5\C51\INC;src;inc
  group SRC
    src/: main.c
