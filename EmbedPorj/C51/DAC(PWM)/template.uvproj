# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\PWM;.\Public
  group App
    ./App/PWM/: pwm.c
  group User
    ./User/: main.c
  group Public
    ./Public/: public.c
