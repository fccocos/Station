# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\ds1302;.\App\smg;.\Public
  group App
    ./App/ds1302/: ds1302.c
    ./App/smg/: smg.c
  group Pubic
    ./Public/: public.c
  group User
    ./User/: main.c
